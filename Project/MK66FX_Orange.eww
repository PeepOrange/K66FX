<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MK66FX_Orange.ewp</path>
    </project>
    <batchBuild />
</workspace>
