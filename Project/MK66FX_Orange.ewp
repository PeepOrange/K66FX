# IAR project MK66FX_Orange.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 NXP MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\APP\Inc; ..\APP\Src; ..\BSP\Inc; ..\BSP\Src; ..\Lib; ..\Startup\IAR-ARM; ..\User\Inc; ..\User\Src; ..\Startup; ..\FatFs
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MK66FX_Orange.hex
  ILINK.IlinkOutputFile: MK66FX_Orange.out
  ILINK.IlinkIcfFile: ..\Linker_Files\MK66xX1M_18.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release_Flash (ARM)
  as the first configuration, except:
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\APP\Inc; ..\APP\Src; ..\BSP\Inc; ..\BSP\Src; ..\Lib; ..\Startup\IAR-ARM; ..\User\Inc; ..\User\Src; ..\Startup
  ILINK.IlinkIcfFile: ..\Linker_Files\MK66RAM256K.icf
  group APP/Inc
    ../APP/Inc/: common.h Include.h isr.h
  group APP/Src
    ../APP/Src/: Common.c isr.c main.c
  group BSP/Inc
    ../BSP/Inc/: MK66_adc.h MK66_cmt.h MK66_dac.h MK66_dma.h MK66_flash.h MK66_ftm.h MK66_gpio.h MK66_i2c.h MK66_lptmr.h MK66_pit.h MK66_port.h MK66_port_cfg.h MK66_rtc.h MK66_sdhc.h MK66_spi.h MK66_systick.h MK66_uart.h MK66_wdog.h
  group BSP/Src
    ../BSP/Src/: MK66_adc.c MK66_cmt.c MK66_dac.c MK66_dma.c MK66_flash.c MK66_ftm.c MK66_gpio.c MK66_i2c.c MK66_lptmr.c MK66_pit.c MK66_port.c MK66_rtc.c MK66_sdhc.c MK66_spi.c MK66_systick.c MK66_uart.c MK66_wdog.c
  group Core
    ../Startup/: Misc.c Misc.h MK66F18.h system_MK66.c system_MK66.h
  group Doc
    ../Doc/: README.md
  group FatFs
    ../FatFs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group Lib
    ../Lib/: core_cm0plus.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group Startup
    ../Startup/IAR-ARM/: startup_MK66F18.s
  group User/Inc
    ../User/Inc/: SEEKFREE_18TFT.h SEEKFREE_28LCD.h SEEKFREE_7725.h SEEKFREE_FUN.h SEEKFREE_IIC.h SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.h SEEKFREE_MPU6050.h SEEKFREE_MT9V032.h SEEKFREE_NRF24L01.h SEEKFREE_OLED.h SEEKFREE_TSL1401.h Serial_oscilloscope.h SPI_TFT_LCD.h
  group User/Src
    ../User/Src/: SEEKFREE_18TFT.c SEEKFREE_32LCD.c SEEKFREE_7725.c SEEKFREE_FUN.c SEEKFREE_IIC.c SEEKFREE_L3G4200D.c SEEKFREE_MMA8451.c SEEKFREE_MPU6050.c SEEKFREE_MT9V032.c SEEKFREE_NRF24L01.c SEEKFREE_OLED.c SEEKFREE_TSL1401.c Serial_oscilloscope.c SPI_TFT_LCD.c
